# Keil uVision project ADAX DT II.uvprojx, settings and files
target ADAX DT II (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F030K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ADAX DT II +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x6
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_cortex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_adc.c stm32f0xx_hal_gpio.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rtc.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: stm32f0xx_it.c adc.c gpio.c i2c.c rtc.c main.c tim.c stm32f0xx_hal_msp.c dma.c display.c button_drv.c button_handler.c open_window.c time_date.c current_state.c adaptive_start.c factory_settings.c temperature.c heating.c hardware_test.c programs.c program_menu.c schedules.c led.c flash.c
  group Application/MDK-ARM
    ./: startup_stm32f030x6.s
software components: CMSIS:CORE 4.1.0
